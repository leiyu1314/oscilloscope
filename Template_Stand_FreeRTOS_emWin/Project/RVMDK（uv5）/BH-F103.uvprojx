# Keil uVision project BH-F103.uvprojx, settings and files
target Led (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER,OS_SUPPORT
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\User\uart;..\..\User\rcc;..\..\User\adc;..\..\User\key;..\..\User\basic_timer;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM3;..\..\User\chipid;..\..\STemWin\inc;..\..\STemWin\Config;..\..\STemWin_Task;..\..\User\sram;..\..\User\lcd;..\..\User\dac;..\..\DSP;..\..\User\AdvanceTim
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c FreeRTOSConfig.h
    ../../User/basic_timer/: bsp_timbasic.c
    ../../User/key/: bsp_key.c
    ../../User/lcd/: bsp_ili9341_lcd_emwin.c bsp_xpt2046_lcd.c
    ../../User/led/: bsp_led.c
    ../../User/sram/: bsp_fsmc_sram.c
    ../../User/uart/: bsp_usart.c
    ../../User/dac/: bsp_dac.c
    ../../User/adc/: bsp_adc.c
    ../../User/AdvanceTim/: bsp_AdvanceTim.c
  group DOC
    ../../Doc/: readme.txt
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM3/: port.c
  group STemWin
    ../../STemWin/Config/: GUIConf.c GUIConf.h GUI_X_Touch_Analog.c LCDConf_FlexColor_Template.c
    ../../STemWin/Lib/: STemWin_CM3_OS_wc16_ARGB.a
    ../../STemWin/OS/: GUI_X_FreeRTOS.c
  group STemWin/task
    ../../STemWin_Task/: Touch_calibration.c DataProcess.c MainTask.c DSO.c
  group DSP
    ../../DSP/: cr4_fft_1024_stm32.s stm32_dsp.h table_fft.h
